# Keil uVision project zeez.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: zeez +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s
    C:/Keil/ARM/Startup/TI/TM4C123/: system_TM4C123.c
  group New Group
    C:/Embbedded programming/Project 2/: main.c newdelay.c port-init.c sevensegment.c switches.c lm4f120h5qr.h newdelay.h port-init.h sevensegment.h switches.h
